## tests/button/testcase.yaml
```yaml
tests:
  led_and_button.unittests:
    integration_platforms:
      - qemu_riscv32
```
